## src/common_uboot/fs/Kconfig
```kconfig
#
# File system configuration
#

menu "File systems"

source "fs/ext4/Kconfig"

source "fs/fat/Kconfig"

endmenu
```
